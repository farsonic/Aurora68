// SPDX-License-Identifier: MPL-2.0
/*
 * tb_card.v - Card P's CPLD (aurora68_pds.v) against a behavioural Macintosh SE.
 *
 * What is modelled (each from the sources docs/22 and docs/18 cite):
 *  - C16M (15.6672 MHz) and C8M (C16M / 2, lagging it by 10 ns), E (C8M / 10, low six clocks and high
 *    four, changing on C8M's falling edges), all three generated by the "board" and inputs to the card.
 *  - The SE's own 68000, still in its socket: it owns the bus after reset and runs read cycles of its own;
 *    it answers /BR with /BG at the end of its current cycle, three-states, and stays off while /BR or
 *    /BGACK is asserted (two- and three-wire arbitration, MC68000 UM section 5.2). Whether it honours a
 *    /BGACK that is already asserted when it comes out of reset is docs/22's open question 1: the parameter
 *    honor is tried both ways.
 *  - The gate array (BBU): /DTACK in S4 for $000000-$DFFFFF, held off while video owns RAM (every third
 *    four-clock slot here), /PMCYC low in processor slots; /VPA for $E00000-$FFFFFF; /BERR after a time-out
 *    for a range nobody answers ($A00000-$AFFFFF here). RAM read data is driven as garbage until 15 ns
 *    before the falling edge entering S7 (Apple: "read data valid from 15 ns into S7", with C8M lagging the
 *    BBU's clock), so a card that latches early reads garbage.
 *  - A 6522 VIA: read data valid from 250 ns after E rises (an NMOS part's delay) until 10 ns after E falls,
 *    garbage otherwise; writes taken on E's fall with /VMA low.
 *  - The card's own parts around the CPLD: four 74LVC16373 latches; the CBTD3384 bus switches are closed
 *    whenever the card is powered, so the CPLD's pins meet the slot directly (the board's pull-ups, 3.3 kOhm
 *    and /RESET 1 kOhm, are tri1 nets here).
 *  - The Pi: the register sequences of emu68/src/psmac/psmac_gpio.c, 20 ns per GPIO register access.
 *
 * Checked continuously: /AS from the card falls only 0-45 ns after a C8M rising edge (the start of S2,
 * never in S3 or S4); the address is stable 15 ns before /AS falls; the card never drives the strobes while
 * the 68000 does; /VMA falls while E is low at least 200 ns before E rises and rises only after E has
 * fallen. The tests then check data, arbitration, resets, stock mode, the fan and the status register.
 */
`timescale 1ns/100ps

module lvc16373_half(input [7:0] d, input le, input oe_n, output [7:0] q);
  reg [7:0] l = 8'h00;
  always @(*) if (le) l = d;
  assign #4 q = oe_n ? 8'bz : l;
endmodule

module tb;
  // ---------------- clocks ----------------
  reg c200 = 0; always #2.5 c200 = ~c200;
  reg c16m = 0; always #31.915 c16m = ~c16m;
  reg c8m = 0;  always @(posedge c16m) c8m <= #10 ~c8m;
  reg [3:0] ecnt = 0; reg e = 0;
  always @(negedge c8m) begin
    ecnt <= (ecnt == 9) ? 0 : ecnt + 1;
    if (ecnt == 9) e <= #5 1'b0; else if (ecnt == 5) e <= #5 1'b1;
  end

  // ---------------- the slot ----------------
  tri1 as_n, uds_n, lds_n, rw, vma_n, dtack_n, vpa_n, berr_n, br_n, bgack_n, reset_n;
  wire bg_n;
  tri [23:1] a;
  tri [15:0] d;
  tri [2:0] fc;
  reg [2:0] ipl_n = 3'b111;
  reg slot_pwr = 1;
  reg pmcyc_n = 1;

  // ---------------- the card ----------------
  tri [15:0] pi_d;
  reg [1:0] pi_a = 0; reg pi_rd = 0, pi_wr = 0; reg [15:0] pi_dv = 0; reg pi_doe = 0;
  assign pi_d = pi_doe ? pi_dv : 16'bz;
  wire txn, iplz, pi_reset;
  wire la0, la8, la16, la24, la_oe_n, ldru, ldrl, ldr_oe_n, ldwu, ldwl, ldw_oe_n;
  wire fan_pwm, led_act;
  reg  fan_tach = 1, stock_sw_n = 1;

  aurora68_pds #(.STOCK_BITS(1)) dut (
    .PI_TXN_IN_PROGRESS(txn), .PI_IPL_ZERO(iplz), .PI_A(pi_a), .PI_CLK(c200), .PI_RESET(pi_reset),
    .PI_RD(pi_rd), .PI_WR(pi_wr), .PI_D(pi_d),
    .LTCH_A_0(la0), .LTCH_A_8(la8), .LTCH_A_16(la16), .LTCH_A_24(la24), .LTCH_A_OE_n(la_oe_n),
    .LTCH_D_RD_U(ldru), .LTCH_D_RD_L(ldrl), .LTCH_D_RD_OE_n(ldr_oe_n),
    .LTCH_D_WR_U(ldwu), .LTCH_D_WR_L(ldwl), .LTCH_D_WR_OE_n(ldw_oe_n),
    .M68K_CLK(c8m), .M68K_FC(fc), .M68K_AS_n(as_n), .M68K_UDS_n(uds_n), .M68K_LDS_n(lds_n), .M68K_RW(rw),
    .M68K_DTACK_n(dtack_n), .M68K_BERR_n(berr_n), .M68K_VPA_n(vpa_n), .M68K_E(e), .M68K_VMA_n(vma_n),
    .M68K_IPL_n(ipl_n), .M68K_RESET_n(reset_n), .M68K_PMCYC_n(pmcyc_n), .M68K_BR_n(br_n),
    .M68K_BGACK_n(bgack_n), .M68K_BG_n(bg_n), .SLOT_PWR(slot_pwr),
    .FAN_PWM(fan_pwm), .FAN_TACH(fan_tach), .STOCK_SW_n(stock_sw_n), .LED_ACT(led_act));
  wire ctrl_oe_n = !dut.bus_enable;       // the card drives the strobes

  // latches: address 1 (A0-A15), address 2 (A16-A23), write data, read data
  wire [15:0] la_q; wire [15:0] la2_q; wire [15:0] lw_q; wire [15:0] lr_q;
  lvc16373_half ua1l(pi_d[7:0],  la0,  la_oe_n, la_q[7:0]);
  lvc16373_half ua1h(pi_d[15:8], la8,  la_oe_n, la_q[15:8]);
  lvc16373_half ua2l(pi_d[7:0],  la16, la_oe_n, la2_q[7:0]);
  lvc16373_half ua2h(pi_d[15:8], la24, 1'b1,    la2_q[15:8]);      // high half not wired on the SE
  lvc16373_half uwl(pi_d[7:0],  ldwl, ldw_oe_n, lw_q[7:0]);
  lvc16373_half uwh(pi_d[15:8], ldwu, ldw_oe_n, lw_q[15:8]);
  lvc16373_half url(d[7:0],  ldrl, ldr_oe_n, lr_q[7:0]);
  lvc16373_half urh(d[15:8], ldru, ldr_oe_n, lr_q[15:8]);
  assign a = {la2_q[7:0], la_q[15:1]};
  assign d = lw_q;
  assign pi_d = lr_q;

  // ---------------- the SE's 68000 ----------------
  parameter HONOR_DEFAULT = 1;
  reg honor = HONOR_DEFAULT;
  reg cpu_oe = 0, cpu_as = 1, cpu_bg = 1, cpu_rw = 1;
  reg [23:1] cpu_a = 0;
  reg board_reset = 1;                    // the SE's power-on reset circuit
  assign reset_n = board_reset ? 1'b0 : 1'bz;
  assign as_n = cpu_oe ? cpu_as : 1'bz;
  assign uds_n = cpu_oe ? cpu_as : 1'bz;
  assign lds_n = cpu_oe ? cpu_as : 1'bz;
  assign rw = cpu_oe ? cpu_rw : 1'bz;
  assign a = cpu_oe ? cpu_a : 23'bz;
  assign bg_n = cpu_bg;
  integer cpu_cycles = 0;
  reg cpu_after_reset = 0;

  task cpu_cycle; begin                   // one read cycle of its own, from ROM space
    @(negedge c8m); cpu_oe = 1; cpu_rw = 1; cpu_a = 23'h200000 + (cpu_cycles & 23'hff);
    @(posedge c8m); #20 cpu_as = 0;
    @(negedge c8m); @(negedge c8m);       // S3, S4
    while (dtack_n && vpa_n && berr_n && reset_n) @(negedge c8m);
    @(negedge c8m); #10 cpu_as = 1;
    cpu_cycles = cpu_cycles + 1;
  end endtask

  always begin : cpu
    if (!reset_n) begin
      cpu_oe = 0; cpu_as = 1; cpu_bg = 1;
      @(posedge reset_n);
      cpu_after_reset = 1;
      repeat (4) @(posedge c8m);
    end
    else if (!br_n || !bgack_n) begin
      if (!(cpu_after_reset && !honor && !bgack_n)) begin
        // arbitration at a cycle boundary: off the bus, /BG while /BR, and stay off while /BGACK
        @(posedge c8m); cpu_oe = 0;
        if (!br_n) cpu_bg = 0;
        while ((!br_n || !bgack_n) && reset_n) begin
          @(posedge c8m);
          if (!bgack_n) cpu_bg = 1;       // the 68000 negates /BG once /BGACK is asserted
          else if (!br_n) cpu_bg = 0;
        end
        cpu_bg = 1; cpu_after_reset = 0;
        repeat (2) @(posedge c8m);
      end else begin
        cpu_after_reset = 0;              // a 68000 that ignores /BGACK after reset: one cycle first
        cpu_cycle;
      end
    end
    else begin
      cpu_after_reset = 0;
      cpu_cycle;
    end
  end

  // ---------------- the gate array, RAM and the VIA ----------------
  reg [15:0] ram [0:65535];
  reg [7:0]  via [0:15];
  reg dtack_r = 1, vpa_r = 1, berr_r = 1;
  reg berr_en = 1;
  assign dtack_n = dtack_r ? 1'bz : 1'b0;
  assign vpa_n = vpa_r ? 1'bz : 1'b0;
  assign berr_n = berr_r ? 1'bz : 1'b0;
  reg [15:0] dbus = 0; reg dbus_oe = 0;
  assign d = dbus_oe ? dbus : 16'bz;
  // video owns RAM in every third slot of four C8M clocks; /PMCYC high then
  integer c8_count = 0; always @(posedge c8m) c8_count = c8_count + 1;
  wire video_slot = ((c8_count / 4) % 3) == 0;
  always @(negedge c8m) pmcyc_n <= #8 video_slot;   // falls at the start of a processor slot (S1)

  reg [23:1] cyc_a; reg cyc_rw; reg cyc_u, cyc_l;
  integer t_dtack;
  always @(negedge as_n) begin : board
    cyc_a = a; cyc_rw = rw;
    #1;
    if (cyc_a >= 23'h700000) begin        // $E00000-$FFFFFF: /VPA
      #15 vpa_r = 0;
    end else if (cyc_a >= 23'h500000 && cyc_a < 23'h580000) begin    // $A00000-$AFFFFF: nobody
      if (berr_en) begin #5000; if (!as_n) berr_r = 0; end
    end else begin
      @(posedge c8m);                     // S4 begins
      if (cyc_a < 23'h200000)             // RAM: wait for a processor slot
        while (video_slot) @(posedge c8m);
      #10 dtack_r = 0; t_dtack = $time;
      if (cyc_rw) begin
        dbus = 16'hBAD0; dbus_oe = 1;     // garbage until 15 ns before the 68000's latch point
        #(192 - 10 - 15) dbus = (cyc_a < 23'h200000) ? ram[cyc_a[16:1]] : {cyc_a[8:1], ~cyc_a[8:1]};
      end
    end
  end
  always @(posedge as_n) begin
    if (!rw === 1'b0 || 1) begin end
    #10 dbus_oe = 0; dtack_r = 1; vpa_r = 1; berr_r = 1;
  end
  // RAM writes: taken as the strobes rise
  always @(posedge as_n) if (rw === 1'b0 && cyc_a < 23'h200000) begin end
  reg [15:0] wdata; reg wu, wl;
  always @(negedge uds_n or negedge lds_n) if (rw === 1'b0) begin #60 wdata = d; wu = !uds_n; wl = !lds_n; end
  always @(posedge as_n) if (rw === 1'b0 && cyc_a < 23'h200000) begin
    if (wu) ram[cyc_a[16:1]][15:8] = wdata[15:8];
    if (wl) ram[cyc_a[16:1]][7:0] = wdata[7:0];
    wu = 0; wl = 0;
  end
  // the VIA on the upper byte, sixteen registers at A9-A12
  reg [15:0] vbus = 0; reg vbus_oe = 0;
  assign d = vbus_oe ? vbus : 16'bz;
  always @(posedge e) if (!vma_n && rw) begin
    vbus = 16'h5A5A; vbus_oe = 1;
    #250 vbus = {via[a[12:9]], via[a[12:9]]};
  end
  always @(negedge e) begin
    if (!vma_n && rw === 1'b0) via[a[12:9]] = d[15:8];
    #10 vbus_oe = 0;
  end

  // ---------------- continuous checks ----------------
  integer errors = 0, checks = 0;
  time t_c8r = 0, t_ach = 0, t_efall = 0, t_erise = 0, t_vma = 0;
  always @(posedge c8m) t_c8r = $time;
  always @(a) if (!la_oe_n) t_ach = $time;
  always @(negedge e) t_efall = $time;
  always @(posedge e) begin
    t_erise = $time;
    if (!vma_n && !ctrl_oe_n && ($time - t_vma) < 200) begin
      errors = errors + 1; $display("FAIL %t: /VMA only %0d ns before E rose", $time, $time - t_vma);
    end
  end
  always @(negedge as_n) if (!ctrl_oe_n) begin
    checks = checks + 1;
    if ($time - t_c8r > 45) begin errors = errors + 1; $display("FAIL %t: /AS fell %0d ns after C8M rose (not in S2)", $time, $time - t_c8r); end
    if ($time - t_ach < 15) begin errors = errors + 1; $display("FAIL %t: address changed %0d ns before /AS", $time, $time - t_ach); end
  end
  always @(negedge vma_n) if (!ctrl_oe_n) begin
    t_vma = $time; checks = checks + 1;
    if (e) begin errors = errors + 1; $display("FAIL %t: /VMA fell while E high", $time); end
  end
  always @(posedge vma_n) if (!ctrl_oe_n) begin
    checks = checks + 1;
    if (e || t_efall < t_vma) begin errors = errors + 1; $display("FAIL %t: /VMA rose before E fell", $time); end
  end
  always @(posedge c200) if (cpu_oe && !ctrl_oe_n) begin
    errors = errors + 1; $display("FAIL %t: the card and the 68000 drive the bus together", $time);
    #1000;
  end

  // ---------------- the Pi (psmac_gpio.c's sequences) ----------------
  task reg_write(input [1:0] r, input [15:0] v); begin
    pi_doe = 1; pi_dv = v; pi_a = r; #20 pi_wr = 1; #20 pi_wr = 0; #20 pi_dv = 0; pi_a = 0; #20;
  end endtask
  task txn_wait(output ok); integer n; begin
    ok = 1; n = 0;
    while (txn === 1'b1 && n < 40000) begin #20; n = n + 1; end
    if (txn === 1'b1) ok = 0;
  end endtask
  task status_write(input [15:0] v); begin reg_write(3, v); pi_doe = 0; end endtask
  task status_read(output [15:0] v); begin
    pi_doe = 0; pi_a = 3; #20 pi_rd = 1; #80 v = pi_d; pi_rd = 0; pi_a = 0; #20;
  end endtask
  task write16(input [23:0] ad, input [15:0] v); reg ok; begin
    reg_write(0, v); reg_write(1, ad[15:0]); reg_write(2, {8'h00, ad[23:16]}); pi_doe = 0;
    txn_wait(ok); if (!ok) begin errors = errors + 1; $display("FAIL %t: write %h never finished", $time, ad); end
  end endtask
  task write8(input [23:0] ad, input [7:0] v); reg ok; begin
    reg_write(0, {v, v}); reg_write(1, ad[15:0]); reg_write(2, {8'h01, ad[23:16]}); pi_doe = 0;
    txn_wait(ok); if (!ok) begin errors = errors + 1; $display("FAIL %t: write8 %h never finished", $time, ad); end
  end endtask
  task read_cycle(input [23:0] ad, input [1:0] hi, output [15:0] v); reg ok; begin
    reg_write(1, ad[15:0]); reg_write(2, {6'h00, hi, ad[23:16]}); pi_doe = 0;
    pi_a = 0; #20 pi_rd = 1;
    txn_wait(ok); #20 v = pi_d; pi_rd = 0; #20;
    if (!ok) begin errors = errors + 1; v = 16'hffff; $display("FAIL %t: read %h never finished", $time, ad); end
  end endtask
  task read16(input [23:0] ad, output [15:0] v); read_cycle(ad, 2'b10, v); endtask
  task read8(input [23:0] ad, output [7:0] v); reg [15:0] w; begin
    read_cycle(ad, 2'b11, w); v = ad[0] ? w[7:0] : w[15:8];
  end endtask
  task expect16(input [127:0] what, input [15:0] got, input [15:0] want); begin
    checks = checks + 1;
    if (got !== want) begin errors = errors + 1; $display("FAIL %t: %0s: got %h, want %h", $time, what, got, want); end
  end endtask
  task expect1(input [255:0] what, input got); begin
    checks = checks + 1;
    if (got !== 1'b1) begin errors = errors + 1; $display("FAIL %t: %0s", $time, what); end
  end endtask
  task pulse_reset; begin                 // psmac_gpio.c pulse_reset(), shortened
    status_write(0); #20000; status_write(2); #5000;
  end endtask

  // ---------------- the tests ----------------
  reg [15:0] v, st; reg [7:0] b; integer i, hi_n, n, before;
  initial begin
    for (i = 0; i < 65536; i = i + 1) ram[i] = i[15:0] ^ 16'h1234;
    for (i = 0; i < 16; i = i + 1) via[i] = 8'h40 + i;

    // 1. Power-up: the card holds /RESET (the classic power-up state) and /BR, drives nothing
    #3000 board_reset = 0;                // the SE's power-on reset ends; the card's still holds
    #2000;
    expect1("power-up: /RESET held by the card", reset_n === 1'b0);
    expect1("power-up: /BR asserted", br_n === 1'b0);
    expect1("power-up: strobes not driven", ctrl_oe_n === 1'b1 && la_oe_n === 1'b1 && ldw_oe_n === 1'b1);
    expect1("power-up: fan at full speed", fan_pwm === 1'b1);

    // 2. The kernel's start (psmac_gpio_init): INIT, 0, then the reset pulse
    status_write(1); #1500; status_write(0); #100; pulse_reset;
    #3000;
    expect1("after the kernel's reset: /BGACK asserted by the card", bgack_n === 1'b0);
    expect1("after the kernel's reset: /BR released", br_n === 1'b1);
    status_read(st);
    expect1("status: card identity bit 12", st[12] === 1'b1);
    expect1("status: bus granted bit 11", st[11] === 1'b1);
    expect1("status: not in stock mode", st[10] === 1'b0);

    // 3. Word and byte cycles to RAM, read data at the 68000's point
    write16(24'h001000, 16'hCAFE); read16(24'h001000, v); expect16("RAM word", v, 16'hCAFE);
    write8(24'h001002, 8'hAB); write8(24'h001003, 8'hCD); read16(24'h001002, v); expect16("RAM bytes", v, 16'hABCD);
    read8(24'h001001, b); expect16("RAM odd byte", {8'h00, b}, 16'h00FE);
    read8(24'h001000, b); expect16("RAM even byte", {8'h00, b}, 16'h00CA);
    for (i = 0; i < 24; i = i + 1) begin
      read16(24'h002000 + 2 * i, v); expect16("RAM read with video hold-off", v, (24'h001000 + i) ^ 16'h1234);
    end
    read16(24'h400100, v); expect16("ROM-space word", v, {8'h80, ~8'h80});

    // 4. The VIA: 6800 cycles against the board's E
    read8(24'hEFE1FE, b); expect16("VIA read", {8'h00, b}, 16'h0040);
    write8(24'hEFE1FE, 8'h99); read8(24'hEFE1FE, b); expect16("VIA write then read", {8'h00, b}, 16'h0099);
    for (i = 1; i < 7; i = i + 1) begin read8(24'hEFE000 + i * 512, b); expect16("VIA registers", {8'h00, b}, 8'h40 + i); end

    // 5. /BERR from the gate array, then the card's own time-out
    read16(24'hA00000, v); status_read(st); expect1("status: BERR after a missing chip", st[9] === 1'b1);
    read16(24'h001000, v); status_read(st); expect1("status: BERR clears on the next cycle", st[9] === 1'b0);

    // 6. A board reset from the kernel with a 68000 that honours /BGACK after reset
    honor = 1; before = cpu_cycles;
    pulse_reset;
    expect1("kernel reset (honouring 68000): /BGACK held", bgack_n === 1'b0);
    expect1("kernel reset (honouring 68000): the 68000 ran no cycle", cpu_cycles == before);
    write16(24'h003000, 16'h1357); read16(24'h003000, v); expect16("RAM after kernel reset", v, 16'h1357);

    // 7. ... and with one that does not (it starts a cycle; the card waits and takes the bus back)
    honor = 0; before = cpu_cycles;
    pulse_reset; #20000;
    expect1("kernel reset (ignoring 68000): it ran a cycle", cpu_cycles > before);
    expect1("kernel reset (ignoring 68000): the card has the bus again", bgack_n === 1'b0 && !ctrl_oe_n);
    write16(24'h003002, 16'h2468); read16(24'h003002, v); expect16("RAM after the 68000's stray cycle", v, 16'h2468);
    honor = 1;

    // 8. The SE's own reset (the programmer's switch)
    board_reset = 1; #30000; board_reset = 0; #20000;
    expect1("SE's reset: the card has the bus again", bgack_n === 1'b0 && !ctrl_oe_n);
    read16(24'h003002, v); expect16("RAM after the SE's reset", v, 16'h2468);

    // 9. RAM cycles aligned with /PMCYC
    status_write(16'h8006);               // ext 0: PMCYC alignment on, time-out on
    for (i = 0; i < 8; i = i + 1) begin read16(24'h004000 + 2 * i, v); expect16("RAM, PMCYC-aligned", v, (24'h002000 + i) ^ 16'h1234); end
    status_write(16'h8004);

    // 10. Stock mode from the kernel, and back
    before = cpu_cycles;
    status_write(16'h8005);               // ext 0: stock
    #500;
    expect1("stock: /BGACK and /BR released", bgack_n === 1'b1 && br_n === 1'b1);
    expect1("stock: nothing driven", ctrl_oe_n === 1'b1 && la_oe_n === 1'b1 && ldw_oe_n === 1'b1);
    expect1("stock: /RESET pulsed", reset_n === 1'b0);
    #120000;
    expect1("stock: /RESET released", reset_n === 1'b1);
    expect1("stock: the SE's 68000 runs", cpu_cycles > before + 20);
    status_read(st); expect1("status: stock bit", st[10] === 1'b1 && st[11] === 1'b0);
    status_write(16'h8004); #20000;
    expect1("leaving stock: the card has the bus again", bgack_n === 1'b0 && !ctrl_oe_n);
    read16(24'h003000, v); expect16("RAM after stock mode", v, 16'h1357);

    // 11. Stock mode from the switch (the override needs no clock)
    stock_sw_n = 0; #20;
    expect1("switch: lines released at once", bgack_n === 1'b1 && br_n === 1'b1 && ctrl_oe_n === 1'b1);
    #120000; before = cpu_cycles; #20000;
    expect1("switch: the SE's 68000 runs", cpu_cycles > before);
    stock_sw_n = 1; #200000;
    expect1("switch opened: the card has the bus again", bgack_n === 1'b0 && !ctrl_oe_n);

    // 12. No SE power: nothing driven, whatever the state
    slot_pwr = 0; #20;
    expect1("no slot power: drivers released", bgack_n === 1'b1 && ctrl_oe_n === 1'b1 && reset_n === 1'b1);
    slot_pwr = 1; #20000;

    // 13. The fan: duty 25 %, and the tachometer
    status_write(16'h9004);               // ext 1: duty 4 of 16
    hi_n = 0; n = 0;
    for (i = 0; i < 4096; i = i + 1) begin @(posedge c8m); n = n + 1; if (fan_pwm) hi_n = hi_n + 1; end
    expect1("fan: duty about 25 %", hi_n > n / 4 - 40 && hi_n < n / 4 + 40);
    status_read(v);
    for (i = 0; i < 37; i = i + 1) begin #5000 fan_tach = 0; #5000 fan_tach = 1; end
    status_read(st);
    expect16("fan: tachometer counted 37 pulses", {10'd0, st[7:2] - v[7:2]}, 16'd37);
    expect1("status: SE power bit", st[0] === 1'b1);

    $display("%0d checks, %0d failures", checks, errors);
    if (errors == 0) $display("PASS"); else $display("FAIL");
    $finish;
  end
  initial begin #20000000 $display("FAIL: simulation time limit"); $finish; end
endmodule
